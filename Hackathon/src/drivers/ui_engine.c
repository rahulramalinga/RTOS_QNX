/*=============================================================================
 * Event Horizon - QNX Screen Software Rendering Engine (v5.0 Master Edition)
 *============================================================================*/
#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <time.h>
#include <math.h>
#include <screen/screen.h>
#include "../include/ui_engine.h"
#include <sys/keycodes.h>

static const unsigned char font_5x7[95][7] = {
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00},{0x04,0x04,0x04,0x04,0x04,0x00,0x04},{0x0A,0x0A,0x0A,0x00,0x00,0x00,0x00},{0x0A,0x0A,0x1F,0x0A,0x1F,0x0A,0x0A},{0x04,0x0F,0x14,0x0E,0x05,0x1E,0x04},
    {0x18,0x19,0x02,0x04,0x08,0x13,0x03},{0x0C,0x12,0x14,0x08,0x15,0x12,0x0D},{0x0C,0x04,0x08,0x00,0x00,0x00,0x00},{0x02,0x04,0x08,0x08,0x08,0x04,0x02},{0x08,0x04,0x02,0x02,0x02,0x04,0x08},
    {0x00,0x04,0x15,0x0E,0x15,0x04,0x00},{0x00,0x04,0x04,0x1F,0x04,0x04,0x00},{0x00,0x00,0x00,0x00,0x0C,0x04,0x08},{0x00,0x00,0x00,0x1F,0x00,0x00,0x00},{0x00,0x00,0x00,0x00,0x00,0x0C,0x0C},
    {0x00,0x01,0x02,0x04,0x08,0x10,0x00},{0x0E,0x11,0x13,0x15,0x19,0x11,0x0E},{0x04,0x0C,0x04,0x04,0x04,0x04,0x0E},{0x0E,0x11,0x01,0x02,0x04,0x08,0x1F},{0x1F,0x02,0x04,0x02,0x01,0x11,0x0E},
    {0x02,0x06,0x0A,0x12,0x1F,0x02,0x02},{0x1F,0x10,0x1E,0x01,0x01,0x11,0x0E},{0x06,0x08,0x10,0x1E,0x11,0x11,0x0E},{0x1F,0x01,0x02,0x04,0x08,0x08,0x08},{0x0E,0x11,0x11,0x0E,0x11,0x11,0x0E},
    {0x0E,0x11,0x11,0x0F,0x01,0x02,0x0C},{0x00,0x0C,0x0C,0x00,0x0C,0x0C,0x00},{0x00,0x0C,0x0C,0x00,0x0C,0x04,0x08},{0x02,0x04,0x08,0x10,0x08,0x04,0x02},{0x00,0x00,0x1F,0x00,0x1F,0x00,0x00},
    {0x08,0x04,0x02,0x01,0x02,0x04,0x08},{0x0E,0x11,0x01,0x02,0x04,0x00,0x04},{0x0E,0x11,0x17,0x15,0x17,0x10,0x0F},{0x0E,0x11,0x11,0x1F,0x11,0x11,0x11},{0x1E,0x11,0x11,0x1E,0x11,0x11,0x1E},
    {0x0E,0x11,0x10,0x10,0x10,0x11,0x0E},{0x1C,0x12,0x11,0x11,0x11,0x12,0x1C},{0x1F,0x10,0x10,0x1E,0x10,0x10,0x1F},{0x1F,0x10,0x10,0x1E,0x10,0x10,0x10},{0x0E,0x11,0x10,0x17,0x11,0x11,0x0F},
    {0x11,0x11,0x11,0x1F,0x11,0x11,0x11},{0x0E,0x04,0x04,0x04,0x04,0x04,0x0E},{0x07,0x02,0x02,0x02,0x02,0x12,0x0C},{0x11,0x12,0x14,0x18,0x14,0x12,0x11},{0x10,0x10,0x10,0x10,0x10,0x10,0x1F},
    {0x11,0x1B,0x15,0x15,0x11,0x11,0x11},{0x11,0x11,0x19,0x15,0x13,0x11,0x11},{0x0E,0x11,0x11,0x11,0x11,0x11,0x0E},{0x1E,0x11,0x11,0x1E,0x10,0x10,0x10},{0x0E,0x11,0x11,0x11,0x15,0x12,0x0D},
    {0x1E,0x11,0x11,0x1E,0x14,0x12,0x11},{0x0F,0x10,0x10,0x0E,0x01,0x01,0x1E},{0x1F,0x04,0x04,0x04,0x04,0x04,0x04},{0x11,0x11,0x11,0x11,0x11,0x11,0x0E},{0x11,0x11,0x11,0x11,0x11,0x0A,0x04},
    {0x11,0x11,0x11,0x15,0x15,0x15,0x0A},{0x11,0x11,0x0A,0x04,0x0A,0x11,0x11},{0x11,0x11,0x11,0x0A,0x04,0x04,0x04},{0x1F,0x01,0x02,0x04,0x08,0x10,0x1F},{0x0E,0x08,0x08,0x08,0x08,0x08,0x0E},
    {0x00,0x10,0x08,0x04,0x02,0x01,0x00},{0x0E,0x02,0x02,0x02,0x02,0x02,0x0E},{0x04,0x0A,0x11,0x00,0x00,0x00,0x00},{0x00,0x00,0x00,0x00,0x00,0x00,0x1F},{0x08,0x04,0x02,0x00,0x00,0x00,0x00},
    {0x00,0x00,0x0E,0x01,0x0F,0x11,0x0F},{0x10,0x10,0x16,0x19,0x11,0x11,0x1E},{0x00,0x00,0x0E,0x10,0x10,0x11,0x0E},{0x01,0x01,0x0D,0x13,0x11,0x11,0x0F},{0x00,0x00,0x0E,0x11,0x1F,0x10,0x0E},
    {0x06,0x09,0x08,0x1C,0x08,0x08,0x08},{0x00,0x0F,0x11,0x11,0x0F,0x01,0x0E},{0x10,0x10,0x16,0x19,0x11,0x11,0x11},{0x04,0x00,0x0C,0x04,0x04,0x04,0x0E},{0x02,0x00,0x06,0x02,0x02,0x12,0x0C},
    {0x10,0x10,0x12,0x14,0x18,0x14,0x12},{0x0C,0x04,0x04,0x04,0x04,0x04,0x0E},{0x00,0x00,0x1A,0x15,0x15,0x11,0x11},{0x00,0x00,0x16,0x19,0x11,0x11,0x11},{0x00,0x00,0x0E,0x11,0x11,0x11,0x0E},
    {0x00,0x00,0x1E,0x11,0x1E,0x10,0x10},{0x00,0x00,0x0D,0x13,0x0F,0x01,0x01},{0x00,0x00,0x16,0x19,0x10,0x10,0x10},{0x00,0x00,0x0E,0x10,0x0E,0x01,0x1E},{0x08,0x08,0x1C,0x08,0x08,0x09,0x06},
    {0x00,0x00,0x11,0x11,0x11,0x13,0x0D},{0x00,0x00,0x11,0x11,0x11,0x0A,0x04},{0x00,0x00,0x11,0x11,0x15,0x15,0x0A},{0x00,0x00,0x11,0x0A,0x04,0x0A,0x11},{0x00,0x00,0x11,0x11,0x0F,0x01,0x0E},
    {0x00,0x00,0x1F,0x02,0x04,0x08,0x1F},{0x02,0x04,0x04,0x08,0x04,0x04,0x02},{0x04,0x04,0x04,0x04,0x04,0x04,0x04},{0x08,0x04,0x04,0x02,0x04,0x04,0x08},{0x00,0x04,0x02,0x1F,0x02,0x04,0x00}
};

static uint64_t get_time_ns(void) {
    struct timespec ts; clock_gettime(CLOCK_MONOTONIC, &ts);
    return (uint64_t)ts.tv_sec * 1000000000ULL + (uint64_t)ts.tv_nsec;
}

int ui_init(ui_context_t *ctx, int width, int height) {
    int usage = SCREEN_USAGE_NATIVE | SCREEN_USAGE_WRITE | SCREEN_USAGE_READ;
    int format = SCREEN_FORMAT_RGBX8888;
    int size[2] = {width, height};
    memset(ctx, 0, sizeof(ui_context_t));
    ctx->width = width; ctx->height = height;
    if (screen_create_context(&ctx->screen_ctx, SCREEN_APPLICATION_CONTEXT) != 0) return -1;
    if (screen_create_window(&ctx->screen_win, ctx->screen_ctx) != 0) return -1;
    screen_set_window_property_iv(ctx->screen_win, SCREEN_PROPERTY_USAGE, &usage);
    screen_set_window_property_iv(ctx->screen_win, SCREEN_PROPERTY_FORMAT, &format);
    screen_set_window_property_iv(ctx->screen_win, SCREEN_PROPERTY_SIZE, size);
    if (screen_create_window_buffers(ctx->screen_win, 2) != 0) return -1;
    screen_get_window_property_pv(ctx->screen_win, SCREEN_PROPERTY_RENDER_BUFFERS, (void **)ctx->screen_buf);
    for (int i = 0; i < 2; i++) {
        screen_get_buffer_property_pv(ctx->screen_buf[i], SCREEN_PROPERTY_POINTER, &ctx->buffer_ptr[i]);
        screen_get_buffer_property_iv(ctx->screen_buf[i], SCREEN_PROPERTY_STRIDE, &ctx->stride[i]);
    }
    screen_create_event(&ctx->screen_ev);
    ctx->rect[0] = 0; ctx->rect[1] = 0; ctx->rect[2] = width; ctx->rect[3] = height;
    ctx->fps = 60.0f; return 0;
}

void ui_shutdown(ui_context_t *ctx) {
    screen_destroy_event(ctx->screen_ev); screen_destroy_window(ctx->screen_win); screen_destroy_context(ctx->screen_ctx);
}

void ui_poll_events(ui_context_t *ctx) {
    int type; ctx->input.key_pressed = 0; ctx->input.mouse_buttons_prev = ctx->input.mouse_buttons;
    while (screen_get_event(ctx->screen_ctx, ctx->screen_ev, 0) == 0) {
        screen_get_event_property_iv(ctx->screen_ev, SCREEN_PROPERTY_TYPE, &type);
        if (type == SCREEN_EVENT_NONE) break;
        if (type == SCREEN_EVENT_POINTER) {
            int pos[2]; screen_get_event_property_iv(ctx->screen_ev, SCREEN_PROPERTY_SOURCE_POSITION, pos);
            ctx->input.mouse_x = pos[0]; ctx->input.mouse_y = pos[1];
            screen_get_event_property_iv(ctx->screen_ev, SCREEN_PROPERTY_BUTTONS, &ctx->input.mouse_buttons);
        } else if (type == SCREEN_EVENT_KEYBOARD) {
            int flags, cap; screen_get_event_property_iv(ctx->screen_ev, SCREEN_PROPERTY_FLAGS, &flags);
            if (flags & KEY_DOWN) {
                screen_get_event_property_iv(ctx->screen_ev, SCREEN_PROPERTY_KEY_CAP, &cap);
                ctx->input.key_sym = cap; ctx->input.key_pressed = 1;
            }
        }
    }
    ctx->input.mouse_clicked = ctx->input.mouse_buttons & ~ctx->input.mouse_buttons_prev;
}

void ui_begin_frame(ui_context_t *ctx) {
    uint64_t now = get_time_ns();
    ctx->delta_time = (float)(now - ctx->last_frame_ns) / 1000000000.0f;
    if (ctx->delta_time <= 0.0f) ctx->delta_time = 0.016f;
    ctx->last_frame_ns = now;
    void *ptr = ctx->buffer_ptr[ctx->buffer_index];
    if (ptr) memset(ptr, 0, ctx->stride[ctx->buffer_index] * ctx->height);
}

void ui_end_frame(ui_context_t *ctx) {
    screen_post_window(ctx->screen_win, ctx->screen_buf[ctx->buffer_index], 1, ctx->rect, 0);
    ctx->buffer_index = (ctx->buffer_index + 1) % 2;
}

void ui_put_pixel(ui_context_t *ctx, int x, int y, uint32_t color) {
    if (x < 0 || x >= ctx->width || y < 0 || y >= ctx->height) return;
    uint32_t *p = (uint32_t *)((uint8_t *)ctx->buffer_ptr[ctx->buffer_index] + y * ctx->stride[ctx->buffer_index] + x * 4);
    *p = color;
}

void ui_put_pixel_blend(ui_context_t *ctx, int x, int y, uint32_t color) {
    if (x < 0 || x >= ctx->width || y < 0 || y >= ctx->height) return;
    uint32_t *p = (uint32_t *)((uint8_t *)ctx->buffer_ptr[ctx->buffer_index] + y * ctx->stride[ctx->buffer_index]) + x;
    uint32_t bg = *p;
    uint32_t rb = (((color & 0xFF00FF) + (bg & 0xFF00FF)) >> 1) & 0xFF00FF;
    uint32_t g  = (((color & 0x00FF00) + (bg & 0x00FF00)) >> 1) & 0x00FF00;
    *p = 0xFF000000 | rb | g;
}

void ui_fill_rect(ui_context_t *ctx, int x, int y, int w, int h, uint32_t color) {
    int x0=x<0?0:x, y0=y<0?0:y, x1=(x+w)>ctx->width?ctx->width:(x+w), y1=(y+h)>ctx->height?ctx->height:(y+h);
    if(x0>=x1||y0>=y1) return;
    for(int r=y0;r<y1;r++) {
        uint32_t *scan = (uint32_t *)((uint8_t *)ctx->buffer_ptr[ctx->buffer_index] + r*ctx->stride[ctx->buffer_index] + x0*4);
        for(int c=0;c<(x1-x0);c++) scan[c] = color;
    }
}

void ui_draw_rect(ui_context_t *ctx, int x, int y, int w, int h, uint32_t color) {
    ui_draw_hline(ctx,x,y,w,color); ui_draw_hline(ctx,x,y+h-1,w,color);
    ui_draw_vline(ctx,x,y,h,color); ui_draw_vline(ctx,x+w-1,y,h,color);
}

void ui_draw_hline(ui_context_t *ctx, int x, int y, int len, uint32_t color) {
    if(y<0||y>=ctx->height||len<=0) return;
    int x0=x<0?0:x, x1=(x+len)>ctx->width?ctx->width:(x+len); if(x0>=x1) return;
    uint32_t *s = (uint32_t*)((uint8_t*)ctx->buffer_ptr[ctx->buffer_index]+y*ctx->stride[ctx->buffer_index]+x0*4);
    for(int i=0;i<(x1-x0);i++) s[i]=color;
}

void ui_draw_vline(ui_context_t *ctx, int x, int y, int len, uint32_t color) {
    if(x<0||x>=ctx->width||len<=0) return;
    int y0=y<0?0:y, y1=(y+len)>ctx->height?ctx->height:(y+len);
    for(int r=y0;r<y1;r++) ui_put_pixel(ctx,x,r,color);
}

void ui_draw_line(ui_context_t *ctx, int x0, int y0, int x1, int y1, uint32_t color) {
    int dx=abs(x1-x0), dy=-abs(y1-y0), sx=x0<x1?1:-1, sy=y0<y1?1:-1, err=dx+dy;
    while(1) { ui_put_pixel(ctx,x0,y0,color); if(x0==x1&&y0==y1) break;
        int e2=2*err; if(e2>=dy){err+=dy;x0+=sx;} if(e2<=dx){err+=dx;y0+=sy;} }
}

void ui_draw_circle(ui_context_t *ctx, int cx, int cy, int radius, uint32_t color) {
    int x=radius, y=0, d=1-radius;
    while(x>=y) {
        ui_put_pixel(ctx,cx+x,cy+y,color); ui_put_pixel(ctx,cx-x,cy+y,color);
        ui_put_pixel(ctx,cx+x,cy-y,color); ui_put_pixel(ctx,cx-x,cy-y,color);
        ui_put_pixel(ctx,cx+y,cy+x,color); ui_put_pixel(ctx,cx-y,cy+x,color);
        ui_put_pixel(ctx,cx+y,cy-x,color); ui_put_pixel(ctx,cx-y,cy-x,color);
        y++; if(d<=0) d+=2*y+1; else { x--; d+=2*(y-x)+1; }
    }
}

void ui_fill_circle(ui_context_t *ctx, int cx, int cy, int radius, uint32_t color) {
    int x=radius, y=0, d=1-radius;
    while(x>=y) {
        ui_draw_hline(ctx,cx-x,cy+y,2*x+1,color); ui_draw_hline(ctx,cx-x,cy-y,2*x+1,color);
        ui_draw_hline(ctx,cx-y,cy+x,2*y+1,color); ui_draw_hline(ctx,cx-y,cy-x,2*y+1,color);
        y++; if(d<=0) d+=2*y+1; else { x--; d+=2*(y-x)+1; }
    }
}

static void swap(int *a, int *b) { int t=*a; *a=*b; *b=t; }
void ui_fill_triangle(ui_context_t *ctx, int x0, int y0, int x1, int y1, int x2, int y2, uint32_t color) {
    if(y0>y1){swap(&x0,&x1);swap(&y0,&y1);} if(y0>y2){swap(&x0,&x2);swap(&y0,&y2);} if(y1>y2){swap(&x1,&x2);swap(&y1,&y2);}
    int h=y2-y0; if(h==0) return;
    for (int i = 0; i < h; i++) {
        int side = (i > y1-y0) || (y1 == y0);
        int sh = side ? (y2-y1) : (y1-y0);
        if (sh == 0) continue;
        float a = (float)i/h;
        float b = (float)(i - (side ? y1-y0 : 0)) / sh;
        int ax = x0 + (int)((x2-x0)*a);
        int bx = side ? (x1 + (int)((x2-x1)*b)) : (x0 + (int)((x1-x0)*b));
        if (ax > bx) swap(&ax, &bx);
        ui_draw_hline(ctx, ax, y0+i, bx-ax+1, color);
    }
}

void ui_draw_char(ui_context_t *ctx, int x, int y, char c, uint32_t color, int scale) {
    if (c < 32 || c > 126) return;
    const unsigned char *g = font_5x7[(int)(c - 32)];
    for (int i = 0; i < 7; i++) {
        unsigned char b = g[i];
        for (int j = 0; j < 5; j++) {
            if (b & (1 << (4-j)))
                ui_fill_rect(ctx, x+j*scale, y+i*scale, scale, scale, color);
        }
    }
}

void ui_draw_text(ui_context_t *ctx, int x, int y, const char *text, uint32_t color, int scale) {
    if (!text) return;
    int cx = x;
    while (*text) {
        if (*text == '\n') { cx = x; y += 8 * scale; }
        else { ui_draw_char(ctx, cx, y, *text, color, scale); cx += 6 * scale; }
        text++;
    }
}
int ui_text_width(const char *text, int scale) { return text?(int)strlen(text)*6*scale-scale:0; }
float ui_get_fps(ui_context_t *ctx) { return 60.0f; }
float ui_get_dt(ui_context_t *ctx) { return ctx->delta_time; }

void ui_draw_scanlines(ui_context_t *ctx) {
    uint32_t *buf = (uint32_t *)ctx->buffer_ptr[ctx->buffer_index]; int stride_px = ctx->stride[ctx->buffer_index]/4;
    for (int y=0; y<ctx->height; y+=4) {
        uint32_t *row = buf + y*stride_px;
        for (int x=0; x<ctx->width; x++) {
            uint32_t bg = row[x];
            uint32_t rb = ((bg & 0xFF00FF) * 3) >> 2; uint32_t g = ((bg & 0x00FF00) * 3) >> 2;
            row[x] = 0xFF000000 | (rb & 0xFF00FF) | (g & 0x00FF00);
        }
    }
}
